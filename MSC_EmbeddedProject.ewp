# IAR project MSC_EmbeddedProject.ewp, settings and files
configuration MSC_EmbeddedProject (ARM, debug)
  General.OGChipSelectEditMenu: MKL25Z128xxx4 Freescale MKL25Z128xxx4
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDiagSuppress: Pa050,Pa084,Pa093,Pa082
  ICCARM.IExtraOptions: --enable_restrict; --guard_calls; -DTARGET_KLXX; -DDEVICE_PORTOUT=1; -D__CORTEX_M0PLUS; -DDEVICE_SEMIHOST=1; -DDEVICE_SLEEP=1; -DTARGET_RELEASE; --diag_suppress=Pa050,Pa084,Pa093,Pa082; -DDEVICE_PORTINOUT=1; -e; -DMBED_ROM_START=0x0; -DTARGET_FF_ARDUINO; -DTARGET_LIKE_CORTEX_M0; -DTARGET_M0P; -DDEVICE_SPISLAVE=1; -DTARGET_KL25Z; -DDEVICE_STDIO_MESSAGES=1; -DDEVICE_ANALOGOUT=1; -DDEVICE_INTERRUPTIN=1; -DDEVICE_SERIAL=1; -DCOMPONENT_NSPE=1; --preinclude=mbed_config.h; -DTARGET_CORTEX_M; -DARM_MATH_CM0PLUS; -DTOOLCHAIN_IAR; -DTARGET_Freescale; -DDEVICE_USTICKER=1; -DDEVICE_I2C=1; -DTARGET_CORTEX; -DCOMPONENT_PSA_SRV_IMPL=1; -DCOMPONENT_PSA_SRV_EMUL=1; -DDEVICE_ANALOGIN=1; -D__CMSIS_RTOS; --no_wrap_diagnostics; -DDEVICE_PWMOUT=1; -DTARGET_LIKE_MBED; -DDEVICE_SPI=1; -D__MBED__=1; -DMBED_RAM_START=0x1ffff000; --diag_suppress=Pe546; -DMBED_ROM_SIZE=0x20000; -DDEVICE_PORTIN=1; -DMBED_RAM_SIZE=0x4000; -DDEVICE_I2CSLAVE=1; -DMBED_BUILD_TIMESTAMP=1553441636.56; -D__MBED_CMSIS_RTOS_CM
  ICCARM.CCIncludePath2: ; mbed; mbed/TARGET_KL25Z/TOOLCHAIN_IAR; mbed/drivers; mbed/hal; mbed/platform
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  AARM.AExtraOptionsV2: -D__CMSIS_RTOS; -D__MBED_CMSIS_RTOS_CM; -D__CORTEX_M0PLUS; -DARM_MATH_CM0PLUS; "-DMBED_CONF_PLATFORM_MAX_ERROR_FILENAME_LEN=16"; "-DMBED_CONF_PLATFORM_ERROR_ALL_THREADS_INFO=0"; "-DMBED_CONF_PLATFORM_STDIO_FLUSH_AT_EXIT=1"; "-DMBED_CONF_PLATFORM_ERROR_FILENAME_CAPTURE_ENABLED=0"; "-DMBED_CONF_PLATFORM_CTHUNK_COUNT_MAX=8"; "-DMBED_CONF_PLATFORM_FORCE_NON_COPYABLE_ERROR=0"; "-DMBED_CONF_PLATFORM_USE_MPU=1"; "-DMBED_CONF_PLATFORM_POLL_USE_LOWPOWER_TIMER=0"; "-DMBED_CONF_TARGET_DEEP_SLEEP_LATENCY=0"; "-DMBED_CONF_PLATFORM_ERROR_REBOOT_MAX=1"; "-DMBED_CONF_PLATFORM_FATAL_ERROR_AUTO_REBOOT_ENABLED=0"; "-DMBED_CONF_PLATFORM_CRASH_CAPTURE_ENABLED=0"; "-DMBED_CONF_PLATFORM_STDIO_BAUD_RATE=9600"; "-DMBED_CONF_PLATFORM_STDIO_CONVERT_TTY_NEWLINES=0"; "-DMBED_CONF_PLATFORM_ERROR_HIST_SIZE=4"; "-DMBED_CONF_PLATFORM_STDIO_BUFFERED_SERIAL=0"; "-DMBED_CONF_TARGET_BOOT_STACK_SIZE=0x1000"; "-DMBED_CONF_PLATFORM_ERROR_HIST_ENABLED=0"; "-DMBED_CONF_PLATFORM_DEFAULT_SERIAL_BAUD_RATE=9600"; "-DMBED_CONF_TARGET_MPU_ROM_END=0x0fffffff"; "-DMBED_CONF_PLATFORM_STDIO_CONVERT_NEWLINES=0"
  OBJCOPY.OOCOutputFile: MSC_EmbeddedProject.srec
  ILINK.IlinkOutputFile: name.out
  ILINK.IlinkIcfFile: mbed/TARGET_KL25Z/TOOLCHAIN_IAR/MKL25Z4.icf
  ILINK.IlinkExtraOptions: --skip_dynamic_initialization; --threaded_lib; --config_def MBED_ROM_START=0x0; --config_def MBED_ROM_SIZE=0x20000; --config_def MBED_RAM_START=0x1ffff000; --config_def MBED_RAM_SIZE=0x4000; --config_def MBED_BOOT_STACK_SIZE=4096
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group mbed
    mbed/drivers/: AnalogIn.h AnalogOut.h BusIn.h BusInOut.h BusOut.h CAN.h DigitalIn.h DigitalInOut.h DigitalOut.h Ethernet.h FlashIAP.h I2C.h I2CSlave.h InterruptIn.h InterruptManager.h LowPowerTicker.h LowPowerTimeout.h LowPowerTimer.h MbedCRC.h PortIn.h PortInOut.h PortOut.h PwmOut.h QSPI.h RawSerial.h Serial.h SerialBase.h SerialWireOutput.h SPI.h SPISlave.h TableCRC.h Ticker.h Timeout.h Timer.h TimerEvent.h UARTSerial.h
    mbed/hal/: analogin_api.h analogout_api.h buffer.h can_api.h can_helper.h crc_api.h critical_section_api.h dma_api.h Driver_Common.h Driver_Storage.h ethernet_api.h flash_api.h flash_data.h gpio_api.h gpio_irq_api.h i2c_api.h itm_api.h LowPowerTickerWrapper.h lp_ticker_api.h mbed_lp_ticker_wrapper.h mpu_api.h pinmap.h port_api.h pwmout_api.h qspi_api.h rtc_api.h serial_api.h sleep_api.h spi_api.h spm_api.h ticker_api.h trng_api.h us_ticker_api.h
    mbed/TARGET_KL25Z/TOOLCHAIN_IAR/: analogin_api.o analogout_api.o arm_math.h clk_freqs.h cmain.o cmsis.h cmsis_armcc.h cmsis_armclang.h cmsis_compiler.h cmsis_gcc.h cmsis_iccarm.h cmsis_nvic.h cmsis_version.h core_armv8mbl.h core_armv8mml.h core_cm0.h core_cm0plus.h core_cm1.h core_cm23.h core_cm3.h core_cm33.h core_cm4.h core_cm7.h core_sc000.h core_sc300.h device.h except.o gpio_api.o gpio_irq_api.o gpio_object.h i2c_api.o mbed.a mbed_board.o mbed_cmsis_conf.h mbed_fault_handler.h mbed_fault_handler.o mbed_overrides.o mbed_retarget.o mbed_rtx.h mbed_sdk_boot.o mbed_tz_context.o MKL25Z4.h mpu_armv7.h mpu_armv8.h objects.h PeripheralNames.h PeripheralPins.h PeripheralPins.o pinmap.o PinNames.h port_api.o PortNames.h pwmout_api.o rtc_api.o RTE_Components.h serial_api.o sleep.o spi_api.o startup_MKL25Z4.o system_MKL25Z4.h system_MKL25Z4.o tz_context.h us_ticker.o
    mbed/platform/: ATCmdParser.h Callback.h CallChain.h CircularBuffer.h critical.h CriticalSectionLock.h CThunk.h CThunkBase.h DeepSleepLock.h DirHandle.h FileBase.h FileHandle.h FileLike.h FilePath.h FileSystemHandle.h FileSystemLike.h FunctionPointer.h LocalFileSystem.h mbed_application.h mbed_assert.h mbed_crash_data_offsets.h mbed_critical.h mbed_debug.h mbed_error.h mbed_error_hist.h mbed_interface.h mbed_mem_trace.h mbed_mktime.h mbed_mpu_mgmt.h mbed_poll.h mbed_power_mgmt.h mbed_preprocessor.h mbed_retarget.h mbed_rtc_time.h mbed_semihost_api.h mbed_sleep.h mbed_stats.h mbed_toolchain.h mbed_version.h mbed_wait_api.h NonCopyable.h platform.h PlatformMutex.h rtc_time.h ScopedLock.h ScopedRamExecutionLock.h ScopedRomWriteLock.h semihost_api.h SharedPtr.h SingletonPtr.h sleep.h Span.h Stream.h toolchain.h Transaction.h wait_api.h
    mbed/: mbed.h
  group MSC_EmbeddedProject
    ./: btCommands.cpp globalConstant.h main.cpp mbed_config.h UART.cpp UART.h
